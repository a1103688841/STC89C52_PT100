# Keil uVision project STC89C52RC.uvproj, settings and files
target STC89C52RC (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: STC89C52RC +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: STC89C52RC.c
